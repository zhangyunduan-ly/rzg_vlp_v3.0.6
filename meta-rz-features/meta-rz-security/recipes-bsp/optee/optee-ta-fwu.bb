require rzg2h_optee-ta-fwu.inc
require rzg2l_optee-ta-fwu.inc
require rzg3s_optee-ta-fwu.inc


#This recipe do_deploy_machine task override do_deploy task.
do_deploy () {
	#Nothing to do
}