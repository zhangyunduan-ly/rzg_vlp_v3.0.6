require rzg2l-optee-ta-sample.inc
require rzg3s-optee-ta-sample.inc

#This recipe do_deploy_machine task override do_deploy task.
do_deploy () {
	#Nothing to do
}