require include/rz-common-security-config.inc
require include/rzg2l-security-config.inc
require rzg2l-firmware-pack.inc
require rzg3s-firmware-pack.inc