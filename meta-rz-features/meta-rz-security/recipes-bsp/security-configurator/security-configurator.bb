require include/rz-common-security-config.inc
require include/rzg2l-security-config.inc
require rzg2l_security-configurator.inc
require rzg3s_security-configurator.inc

#This recipe do_deploy_machine task override do_deploy  task.
do_deploy () {
	#Nothing to do
}