require include/rz-common-security-config.inc
require include/rzg2l-security-config.inc
require rzg2l-flash-writer.inc
require include/rzg2h-security-config.inc
require rzg2h-flash-writer.inc
require rzg3s-flash-writer.inc
