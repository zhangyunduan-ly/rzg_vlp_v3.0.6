require include/rz-common-security-config.inc
require include/rzg2l-security-config.inc
require rzg2l-trusted-firmware-a.inc
require include/rzg2h-security-config.inc
require rzg2h-trusted-firmware-a.inc
require rzg3s-trusted-firmware-a.inc
inherit python3native
