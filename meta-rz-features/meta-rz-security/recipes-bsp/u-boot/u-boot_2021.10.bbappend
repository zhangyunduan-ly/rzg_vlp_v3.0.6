require include/rz-common-security-config.inc
require include/rzg2l-security-config.inc
require rzg2l-u-boot.inc
require rzg3s-u-boot.inc